require stegos-init.inc
require stegos-shell.inc
require stegos-docker.inc
