# Create the /stegos mountpoint in the root filesystem
dirs755 += "/stegos"
