# Fix race condition in do_install for elfutils-native
PARALLEL_MAKEINST = ""
