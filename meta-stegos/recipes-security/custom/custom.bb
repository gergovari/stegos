SRC_URI += " \
    file://stegos-custom.te \
    file://stegos-custom.fc \
    file://stegos-custom.if \
"

inherit refpolicy
